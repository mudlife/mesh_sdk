# Keil uVision project mesh.uvproj, settings and files
target Mesh_Source_Light (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT
  c include: .\app;.\dev;.\os;.\inc
  group startup
    ./: STARTUP.A51
  group main
    ./src/: main.c
  group os
    ../mesh_lib_src/os/: os.c
  group phy
    ../mesh_lib_src/phy/: netstack_phy.c
  group mac
    ../mesh_lib_src/mac/: netstack_mac.c
  group dev
    ./dev/: delay.c spi.c flash.c system.c
  group net
    ../mesh_lib_src/net/: netstack_net.c
  group app
    ./app/: netstack_app_light.c netstack_app_plug.c netstack_app_fan.c netstack_app_zwr140.c
  group lib
    ./lib/: mesh.LIB
target Mesh_Source_Plug (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,PLUG,NET_RESET
  c include: .\app;.\dev;.\os;.\inc
target Mesh_Source_Fan (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,FAN,NET_RESET
  c include: .\app;.\dev;.\os;.\inc
target Mesh_Source_ZWR140 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT
  c include: .\app;.\dev;.\os;.\inc
target Mesh_Gene_Lib (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex (library)
  AfterMake: E:\公司文件\mesh灯版本管理\mesh_wl2633A1\mesh_pro\gen_lib.bat
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT
  c include: .\app;.\dev;.\os;.\inc
target Mesh_SDK (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT
  c include: .\app;.\dev;.\os;.\inc
target Mesh_SDK_Light (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT,NET_RESET
  c include: .\app;.\dev;.\os;.\inc
target Mesh_SDK_Fan (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,FAN,NET_RESET
  c include: .\app;.\dev;.\os;.\inc
target Mesh_SDK_ZWR140 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: mesh +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: LOG,LIGHT,NET_RESET
  c include: .\app;.\dev;.\os;.\inc
